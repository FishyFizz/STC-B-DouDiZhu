# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: SizeSpeed=1
  group stack
    ./src/: stack.c stack.inc stack.h
  group xstack
    ./src/: xstack.c xstack.h xstack.inc xbp_helper.a51
  group utils
    ./src/: random.c spin.c random.h spin.h bit_ops.h
  group drivers
    ./src/: adsensor.c button.c ds1302.c rs485.c usbcom.c adsensor.h button.h ds1302.h rs485.h usbcom.h seg_led.c seg_led.h
  group semaphore
    ./src/: semaphore.c semaphore.h
  group events
    ./src/: events.c events.h
  group scheduler
    ./src/: scheduler.c scheduler.h
  group timer0_isr
    ./src/: timer0_isr_c.c timer0_isr.h timer0_isr.a51
  group syscall
    ./src/: syscall_c.c syscall.h syscall.a51
  group startup
    ./src/: main.c STARTUP.A51
  group stc
    ./src/: global.h STC15Fxxxx.H stc15fxxxx.inc config.h
  group doudizhu
    ./src/: game_logic.c game_proc.c game_ui.c game_logic.h game_proc.h game_ui.h
